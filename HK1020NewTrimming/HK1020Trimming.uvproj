# Keil uVision project HK1020Trimming.uvproj, settings and files
target HK1020 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: HK1020Trimming_Pro +hex
  c flags: Optimize=4 SizeSpeed=1
  group UserPrg
    ./: TC18B20NewTrimming.c
  group DelayTime
    ./: DelayTime.c
  group WRData
    ./: RWData.c
  group SysInit
    ./: SystemInit.c
  group SendData
    ./: TranslateData.c
