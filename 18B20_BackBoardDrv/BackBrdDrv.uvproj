# Keil uVision project BackBrdDrv.uvproj, settings and files
target BackBrdDrv (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: BackBrdDrv_Pro +hex
  c flags: Optimize=4 SizeSpeed=1
  group Com1Com
    ./: DataTrans.c
  group PCCom
    ./: pc.c
  group TstBrdContrl
    ./: TstBrdContrl.c
  group DelayTime
    ./: DelayTime.c
  group SystemInit
    ./: SystemInit.c
  group MainPro
    ./: MainPro.c
  group Chamber
    ./: Chamber.c
  group CFG
    ./: cfguo.c
  group Power
    ./: NewPower.c
  group Crc16_MODBUS
    ./: Crc16_MODBUS.c
